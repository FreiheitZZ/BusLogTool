# Keil uVision project UartLogTool.uvprojx, settings and files
target UartLogTool (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F401CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F401xx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: ..\Source\Platform\CPU\CORE;..\Source\Platform\LIB\FWLIB\inc;..\Source\Platform\RTOS\FreeRTOS\include;..\Source\Platform\RTOS\FreeRTOS\portable\RVDS\ARM_CM4F;..\Source\Platform\CPU\stm32f4xx;..\Source\Driver\USB\STM32_USB_Device_Library\Class\cdc\inc;..\Source\Driver\USB\STM32_USB_Device_Library\Core\inc;..\Source\Driver\USB\STM32_USB_OTG_Driver\inc;..\Source\Driver\USB\USB_APP;..\Source\Module\Communicate;..\Source\Common
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group User
    ../Source/Main/: main.c
    ../Source/Platform/CPU/stm32f4xx/: stm32f4xx_it.c system_stm32f4xx.c
  group Common
    ../Source/Common/: delay.c malloc.c sys.c usart.c RingBuffer.c debug_assert.c Common.c
  group Driver
    ../Source/Driver/Uart/: Uart.c
    ../Source/Driver/Uart/Uart_STM32F407/: UartSTM32F407.c
  group Device
    ../Source/Device/EXTI/: exti.c
    ../Source/Device/TIMER/: timer.c
    ../Source/Device/LED/: led.c
  group CORE
    ../Source/Platform/CPU/CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../Source/Platform/LIB/FWLIB/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group FreeRTOS_CORE
    ../Source/Platform/RTOS/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../Source/Platform/RTOS/FreeRTOS/portable/MemMang/: heap_4.c
    ../Source/Platform/RTOS/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group README
    ../: readme.txt
  group Module
    ../Source/Module/Initial/: Initial.c
    ../Source/Module/StandBy/: StandByAcceptor.c StandByChecker.c StandByExecutor.c StandBySequencer.c
    ../Source/Module/WatchDogTimer/: WatchDogTimerManager.c
    ../Source/Module/WatchDogTimer/forMN103LF15/: WatchDogTimerMN103LF15.c
    ../Source/Module/Communicate/: Communicate.c
  group Platform
    ../Source/Platform/RTOS/: TaskConfig.c
  group USB_OTG
    ../Source/Driver/USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_DEVICE
    ../Source/Driver/USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../Source/Driver/USB/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group USB_APP
    ../Source/Driver/USB/USB_APP/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
